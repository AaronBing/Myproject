# IAR project STSPIN32F0.ewp, settings and files
configuration STSPIN32F0A_Potentiometer (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031x6 ST STM32F031x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F031x6; NO_UART_COMM; NO_PID; NO_HALL_SENSORS; NO_ALL_WINDINGS_ENERGIZATION; NO_FIXED_HALL_DELAY; NO_PWM_ON_BEMF_SENSING; NO_MC_FAN_4PP_24V; NO_MC_RS_57BL54; NO_MC_2036_U_024_B_K312; MC_BR2804_1700_KV_1; DELTA_6STEP_TABLE; COMPLEMENTARY_DRIVE; VOLTAGE_MODE; POTENTIOMETER; NO_CURRENT_SENSE_ADC; NO_VBUS_SENSE_ADC; NO_TEMP_SENSE_ADC; NO_BEMF_RECORDING; NO_SPEED_SENDING; SPEED_RAMP
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\STEVAL-SPIN3202; ..\..\..\..\..\..\..\Drivers\BSP\Components\stspin32f0; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STEVAL-SPIN3202-6STEPS-POTENTIOMETER.bin
  ILINK.IlinkOutputFile: STSPIN32F0A_Potentiometer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STSPIN32F0A_Uart (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F031x6; UART_COMM; NO_PID; NO_HALL_SENSORS; NO_ALL_WINDINGS_ENERGIZATION; NO_FIXED_HALL_DELAY; NO_PWM_ON_BEMF_SENSING; NO_MC_FAN_4PP_24V; NO_MC_RS_57BL54; NO_MC_2036_U_024_B_K312; MC_BR2804_1700_KV_1; DELTA_6STEP_TABLE; COMPLEMENTARY_DRIVE; VOLTAGE_MODE; NO_POTENTIOMETER; NO_CURRENT_SENSE_ADC; NO_VBUS_SENSE_ADC; NO_TEMP_SENSE_ADC; NO_BEMF_RECORDING; NO_SPEED_SENDING; SPEED_RAMP
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STEVAL-SPIN3202; ..\..\..\..\..\..\..\Drivers\BSP\Components\stspin32f0; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc
  OBJCOPY.OOCOutputFile: STEVAL-SPIN3202-6STEPS-UART.bin
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/stspin32f0/: stspin32f0.c
  group Drivers/BSP/STEVAL-SPIN3202
    ../../../../../../../Drivers/BSP/STEVAL-SPIN3202/: STEVAL-SPIN3202.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c
  group Example/EWARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f031x6.s
  group Example/User
    ../../Src/: main_32F0.c stspin32f0_hal_msp.c stspin32f0_it.c
    ../../Inc/: MC_SixStep_param_2036_U_024_B_K312.h MC_SixStep_param_32F0.h MC_SixStep_param_BR2804_1700_KV_1.h MC_SixStep_param_FAN_4PP_24V.h MC_SixStep_param_RS_57BL54.h
  group Middlewares/MC_6Step_Lib
    ../../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART_serial_com
    ../../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
